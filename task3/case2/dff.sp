*第一组dff
M0 N1 CLK N3 0 N_50n L = 50N W = 0.5U
M1 N1 CLKB N3 VDD P_50n L = 50N W = 1U
M2 N1 CLKB VIN 0 N_50n L = 50N W = 0.5U
M3 N1 CLK VIN VDD P_50n L = 50N W = 1U
* M4 N2 N1 0 0 N_50n L = 50N W = 0.5U
* M5 N2 N1 VDD VDD P_50n L = 50N W = 1U
M6 N3 N2 0 0 N_50n L = 50N W = 0.5U
M7 N3 N2 VDD VDD P_50n L = 50N W = 1U
M8 N4 CLK N6 VDD P_50n L = 50N W = 1U
M9 N4 CLKB N6 0 N_50n L = 50N W = 0.5U
M10 N4 CLK N3 0 N_50n L = 50N W = 0.5U
M11 N4 CLKB N3 VDD P_50n L = 50N W = 1U
* M12 N5 N4 0 0 N_50n L = 50N W = 0.5U
* M13 N5 N4 VDD VDD P_50n L = 50N W = 1U
M14 N6 N5 0 0 N_50n L = 50N W = 0.5U
M15 N6 N5 VDD VDD P_50n L = 50N W = 1U
M16 CLKB CLK 0 0 N_50n L = 50N W = 0.5U
M17 CLKB CLK VDD VDD P_50n L = 50N W = 1U
*第二组dff
M18 N7 CLK N3 0 N_50n L = 50N W = 0.5U
M19 N7 CLKB N3 VDD P_50n L = 50N W = 1U
M20 N7 CLKB N6 0 N_50n L = 50N W = 0.5U
M21 N7 CLK N6 VDD P_50n L = 50N W = 1U
M22 N8 N7 0 0 N_50n L = 50N W = 0.5U
M23 N8 N7 VDD VDD P_50n L = 50N W = 1U
M24 N9 N8 0 0 N_50n L = 50N W = 0.5U
M25 N9 N8 VDD VDD P_50n L = 50N W = 1U
M26 N10 CLK N12 VDD P_50n L = 50N W = 1U
M27 N10 CLKB N12 0 N_50n L = 50N W = 0.5U
M28 N10 CLK N9 0 N_50n L = 50N W = 0.5U
M29 N10 CLKB N9 VDD P_50n L = 50N W = 1U
M30 N11 N10 0 0 N_50n L = 50N W = 0.5U
M31 N11 N10 VDD VDD P_50n L = 50N W = 1U
M32 N12 N11 0 0 N_50n L = 50N W = 0.5U
M33 N12 N11 VDD VDD P_50n L = 50N W = 1U

*rst
M34 M34D N4 0 0 N_50n L = 50N W = 0.5U
M35 N5 RST M34D 0 N_50n L = 50N W = 0.5U
M36 N5 RST VDD VDD P_50n L = 50N W = 1U
M37 N5 N4 VDD VDD P_50n L = 50N W = 1U

M38 M38D RST 0 0 N_50n L = 50N W = 0.5U
M39 N2 N1 M38D 0 N_50n L = 50N W = 0.5U
M40 N2 N1 VDD VDD P_50n L = 50N W = 1U
M41 N2 RST VDD VDD P_50n L = 50N W = 1U

VCLK CLK 0 PULSE 0 1 5N 0.01N 0.01N 4.99N 10N
VDD VDD 0 1
* VIN VIN 0 PULSE 0 1 2.5N 0.01N 0.01N 4.99N 10N
VIN VIN 0 PWL 0 0 2.49N 0 2.5N 1 7.49N 1 7.5N 0 17.49N 0 17.5N 1 18.49N 1 18.5N 0 22.49N 0 22.5N 1 30.49N 1 30.5N 0 42.49N 0 42.5N 1 47.49N 1 47.5N 0 57.49N 0 57.5N 1 62.49N 1 62.5N 0
VRST RST 0 PWL 0 1 27.49N 1 27.5N 0 28.49N 0 28.5N 1 39.99N 1 40N 0
.INCLUDE 'C:\sdsy\model1\rf018.l'
* .DC VINB 0 1 0.001
* .DC VINA 0 1 0.001
.TRAN 0.01N 70N START = 0
.measure tran thl when V(N6) = 0.5 fall = 1
.measure tran tlh when V(N6) = 0.5 rise = 1

.OPTION LIST NODE BRIEF=1
.OPTION POST=3

.END
